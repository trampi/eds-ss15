# Keil uVision project comp.uvproj, settings and files
target CoffeeAO (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: comp
  c flags: Optim=1
  c define: QM_TICK QM_ActiveObject
  c include: .\bombqmbsp;..\..\..\..\..\..\..\CPU_Platforms\ARM\ARM7\MCB2300\include;..\..\..\..\..\..\..\Framewworks\Quantum\qpc_5.3.1\qpc\ports\arm7\Keil;..\..\..\..\..\..\..\Framewworks\Quantum\qpc_5.3.1\qpc\include;.\src;.\src\coffee
  asm misc: --predefine "REMAP SETL {TRUE}"  --predefine "RAM_MODE SETL {TRUE}"
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x4fff
  memory RVCT9: RAM 0x40005000 size 0x3fff
  memory RVCT10: RAM 0x7fe00000 size 0x1f
  link misc: --entry 0x40000000
  group startup
    ./src/: Retarget.c startup.s swi_interrup.s
  group drivers
    ./bsp/: LCD_4bit.c led.c Serial.c adwheel.c timer.c button.c lc2378rtc.c
  group qeplib
    ../../../../../../../Framewworks/Quantum/qpc_5.3.1/qpc/qep/source/: qep.c qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c qmsm_dis.c qmsm_in.c qmsm_ini.c
  group qflib
    ../../../../../../../Framewworks/Quantum/qpc_5.3.1/qpc/qf/source/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c qvanilla.c
  group coffee
    ./src/coffee/: coffee.c main.c alarm.c
  group bsp
    ./src/: qmbsp.c
